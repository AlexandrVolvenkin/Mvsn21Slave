# IAR project Mvsn21Slave.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x40
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m48 ATmega48
  ICCAVR.IExtraOptions: --string_literals_in_flash
  ICCAVR.newCCIncludePaths: D:\Projects\CurrentProjects\CautoProjects\Mvsn21\Mvsn21Slave\include; D:\Projects\CurrentProjects\CautoProjects\Mvsn21\Mvsn21Slave\Modbus
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 2
  ICCAVR.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm48.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    src/: Crc.cpp main.cpp MeasurementChannel.cpp Mvsn21.cpp Platform.cpp
    Modbus/: Modbus.cpp ModbusRTU.cpp
